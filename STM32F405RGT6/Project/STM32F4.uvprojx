# Keil uVision project STM32F4.uvprojx, settings and files
target STM32F4 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries;..\User;..\BSP;..\MPU6050;..\APP;..\RmLib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: stm32f4xx_it.c global_define.h global_varialbe.c main.c remote_control.c remote_control.h pid.h pid.c main.h
  group MPU6050
    ../MPU6050/: mpu6050_driver.c mpu6050_driver.h mpu6050_i2c.c mpu6050_i2c.h mpu6050_interrupt.c mpu6050_interrupt.h
  group BSP
    ../BSP/: bsp.c bsp.h can2.c can2.h usart1.c usart1.h delay.c delay.h tim6.c tim6.h led.c led.h laser.c laser.h usart2.c usart2.h pwm.c pwm.h usart3.c usart3.h tim2.c tim2.h can1.c can1.h
  group Libraries
    ../Libraries/: misc.c stm32f4xx_tim.c stm32f4xx_rcc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_syscfg.c system_stm32f4xx.c startup_stm32f4xx.s stm32f4xx_i2c.c stm32f4xx_wwdg.c stm32f4xx_flash.c stm32f4xx_dma.c
  group APP
    ../APP/: app.c app_chassis.c app.h app_chassis.h
  group RmLib
    ../RmLib/: common.h pid_regulator.h
software components: CMSIS:CORE 4.3.0
